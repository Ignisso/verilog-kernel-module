## kernel_module/Config.in
```kconfig
config BR2_PACKAGE_KERNEL_MODULE
	bool "kernel_module"
	help
		Kernel module module for sykom lecture.
```
